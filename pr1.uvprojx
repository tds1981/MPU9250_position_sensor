# Keil uVision project pr1.uvprojx, settings and files
target Target 1 (6140000::V6.14::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project1 +hex
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_FULL_LL_DRIVER,USE_HAL_DRIVER,STM32F103xB
  c include: ..\MPU9250_position_sensor
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group scr
    ./: I2C.c I2C.h main.c main.h OLED_SSD1306.c OLED_SSD1306.h Rington.c Rington.h MPU9250_progI2C.c MPU9250_progI2C.h
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
